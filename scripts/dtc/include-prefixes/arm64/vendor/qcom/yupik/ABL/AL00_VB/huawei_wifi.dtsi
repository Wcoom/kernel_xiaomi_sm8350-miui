&huawei_wifi_info{
    compatible = "huawei,hw_wifi_info";
    status = "ok";
    wifi,pubfile_id = "abl_al00_va";
    wifi,chiptype = "WIFI_QUALCOMM_WCN6750";
    wifi,ini_type = "abl_7315";
};